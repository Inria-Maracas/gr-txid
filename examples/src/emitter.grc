options:
  parameters:
    author: Cyrille Morin
    category: Custom
    generate_options: no_gui
    id: emitter
    output_language: python
    run_options: run
    title: Tx Id Emitter
  states: {}

blocks:
- name: chip_seq_0
  id: variable
  parameters:
    value: (0,0,1,1,1,1,1,0,0,0,1,0,0,1,0,1)
  states: {}
- name: chip_seq_7
  id: variable
  parameters:
    value: (1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0)
  states: {}
- name: chip_seq_A
  id: variable
  parameters:
    value: (0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 1)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: full_header
  id: variable
  parameters:
    value: zpad+preamble_len+preamble_guard_len+ header_len + header_guard_len
  states: {}
- name: header_guard_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '400'
  states: {}
- name: header_len_0
  id: variable
  parameters:
    value: '320'
  states: {}
- name: payload_guard_len
  id: variable
  parameters:
    value: '200'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '560'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: (1.00000000000000 + 0.00000000000000j, -0.0198821876650702 - 0.999802329770066j, 0.0596151251698190 + 0.998221436781933j, -0.992892073701974 + 0.119018191801903j, -0.980297366804636 + 0.197527397177953j, 0.293850274337919 + 0.955851461405761j, -0.405525320812986 - 0.914083811354038j, 0.848983362091364 - 0.528419578452620j, 0.754564620158230 - 0.656225749270376j, -0.780057308185211 - 0.625708075660561j, 0.888282612749130 + 0.459297289222982j, -0.255616632440464 + 0.966778225458040j, -0.0198821876650804 + 0.999802329770065j, 0.971669340040416 - 0.236344438532879j, -0.869320274439587 + 0.494249188616716j, -0.727878810369485 - 0.685705795086423j, -0.905840393665518 - 0.423619146408540j, -0.0992537989080696 + 0.995062150522427j, -0.255616632440477 - 0.966778225458036j, 0.804316565270771 - 0.594201028971703j, 0.511435479103437 - 0.859321680579653j, -0.992892073701971 - 0.119018191801923j, 0.949820131727787 - 0.312796607022213j, 0.700042074569421 + 0.714101599096754j, 0.949820131727768 + 0.312796607022273j, -0.177997895677522 - 0.984030867978426j, 0.641093637592130 + 0.767462668693983j, -0.331619278552096 + 0.943413299722125j, 0.216978808106213 + 0.976176314419074j, 0.700042074569433 - 0.714101599096743j, -0.177997895677626 + 0.984030867978407j, -0.905840393665558 + 0.423619146408453j, -0.476867501428628 + 0.878975190822367j, 0.987375341936355 - 0.158398024407083j, -0.671098428359002 + 0.741368261698650j, -0.999209397227295 - 0.0397565150970890j, -0.780057308185194 + 0.625708075660582j, 0.987375341936324 + 0.158398024407273j, -0.827304032543040 + 0.561754428320796j, -0.980297366804605 - 0.197527397178109j, -0.827304032543027 + 0.561754428320816j, 0.987375341936332 + 0.158398024407226j, -0.780057308185292 + 0.625708075660460j, -0.999209397227299 - 0.0397565150969950j, -0.671098428359083 + 0.741368261698577j, 0.987375341936350 - 0.158398024407110j, -0.476867501428484 + 0.878975190822446j, -0.905840393665478 + 0.423619146408624j, -0.177997895677642 + 0.984030867978404j, 0.700042074569508 - 0.714101599096669j, 0.216978808106132 + 0.976176314419092j, -0.331619278552151 + 0.943413299722105j, 0.641093637592190 + 0.767462668693933j, -0.177997895677511 - 0.984030867978428j, 0.949820131727754 + 0.312796607022316j, 0.700042074569284 + 0.714101599096888j, 0.949820131727893 - 0.312796607021891j, -0.992892073701961 - 0.119018191802010j, 0.511435479103736 - 0.859321680579474j, 0.804316565270626 - 0.594201028971898j, -0.255616632440350 - 0.966778225458070j, -0.0992537989081486 + 0.995062150522419j, -0.905840393665482 - 0.423619146408617j, -0.727878810369385 - 0.685705795086529j, -0.869320274439717 + 0.494249188616486j, 0.971669340040621 - 0.236344438532038j, -0.0198821876652695 + 0.999802329770062j, -0.255616632440926 + 0.966778225457918j, 0.888282612749188 + 0.459297289222869j, -0.780057308185057 - 0.625708075660753j, 0.754564620158670 - 0.656225749269870j, 0.848983362091728 - 0.528419578452034j, -0.405525320812299 - 0.914083811354343j, 0.293850274337947 + 0.955851461405753j, -0.980297366804665 + 0.197527397177809j, -0.992892073702018 + 0.119018191801536j, 0.0596151251691726 + 0.998221436781972j, -0.0198821876650031 - 0.999802329770067j, 1.00000000000000 + 4.46840285540623e-13j)
  states: {}
- name: preamble_guard_len
  id: variable
  parameters:
    value: '40'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: len(preamble)
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: shr_field_chips
  id: variable
  parameters:
    value: chip_seq_0 * 8 + chip_seq_7 + chip_seq_A
  states: {}
- name: sizes
  id: variable_struct
  parameters:
    field0: zpad
    field1: preamble
    field2: preambleGuard
    field3: header
    field4: headerGuard
    field5: payload
    field6: payloadGuard
    value0: '3000'
    value1: len(preamble)
    value2: '40'
    value3: '320'
    value4: '100'
    value5: '560'
    value6: space_between_packets
  states: {}
- name: zpad
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: (max_gain-min_gain)
    comment: Vary signal amplitude
    freq: gain_freq
    maxoutbuf: '1'
    offset: min_gain
    phase: '0'
    samp_rate: '100'
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: |-
      Avoid USRP
      saturation/clipping
    const: '0.06'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: payload_len
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if (is_noise) else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if (is_random_source) else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_stream_mux_3
  id: blocks_stream_mux
  parameters:
    lengths: '[zpad, preamble_len, preamble_guard_len, header_len, header_guard_len]'
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_stream_mux_4
  id: blocks_stream_mux
  parameters:
    lengths: '[full_header, payload_len, payload_guard_len]'
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"length"'
    packet_len: '5'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: full_header
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: (full_header+payload_len + payload_guard_len)/float(full_header)
    comment: Used for USRP burst mode
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: shr_field_chips
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Header content
    repeat: 'True'
    type: byte
    vector: '[tx_id, tx_id, tx_id, tx_id, tx_id]'
  states: {}
- name: blocks_vector_source_x_0_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,0,0xA7)
  states: {state: disabled}
- name: center_freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: c
    type: eng_float
    value: 433e6
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Packet modulation
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: '2'
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: length
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'True'
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: filter_width
  id: parameter
  parameters:
    label: Tx Filter Bandwidth
    short_id: b
    type: eng_float
    value: '0'
  states: {}
- name: gain_freq
  id: parameter
  parameters:
    label: gain_frequency
    short_id: f
    type: eng_float
    value: '7'
  states: {}
- name: is_noise
  id: parameter
  parameters:
    short_id: r
    type: intx
    value: '0'
  states: {}
- name: is_random_source
  id: parameter
  parameters:
    short_id: R
    type: intx
    value: '0'
  states: {}
- name: max_gain
  id: parameter
  parameters:
    label: maximum_gain
    short_id: M
    type: eng_float
    value: '0.1'
  states: {}
- name: min_gain
  id: parameter
  parameters:
    label: minimum_gain
    short_id: m
    type: eng_float
    value: '0.001'
  states: {}
- name: nb_packets
  id: parameter
  parameters:
    short_id: N
    type: intx
    value: '70000'
  states: {}
- name: null_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_2
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_3
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: oqpsk_0
  id: oqpsk
  parameters:
    roll_off_factor: '0.1'
    samp_rate: samp_rate
    samples_per_symbols: samp_rate//800000
  states: {state: disabled}
- name: packet_len
  id: parameter
  parameters:
    short_id: L
    type: intx
    value: '400'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: port
  id: parameter
  parameters:
    label: port_number
    short_id: P
    type: intx
    value: '3580'
  states: {}
- name: preamble_vect
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: preamble
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    short_id: a
    type: intx
    value: '5000000'
  states: {}
- name: space_between_packets
  id: parameter
  parameters:
    short_id: s
    type: intx
    value: '200'
  states: {}
- name: tx_id
  id: parameter
  parameters:
    short_id: T
    type: intx
    value: '0'
  states: {}
- name: txid_head_0
  id: txid_head
  parameters:
    blocking: 'True'
    comment: |-
      Ensure only one 
      packet is generated
    num_items: full_header
    type: complex
    vlen: '1'
  states: {}
- name: txid_udp_trigger_0
  id: txid_udp_trigger
  parameters:
    ip_addr: 0.0.0.0
    port: port
    tx_number: tx_id
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: filter_width
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: internal
    dev_args: '""'
    gain0: usrp_tx_gain
    len_tag_name: '"packet_len"'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: usrp_tx_gain
  id: parameter
  parameters:
    label: gain
    short_id: G
    type: intx
    value: '3'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_selector_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_selector_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_repeat_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_stream_mux_3, '3']
- [blocks_multiply_xx_0, '0', blocks_stream_mux_4, '1']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_selector_0, '0', blocks_multiply_xx_0, '0']
- [blocks_selector_1, '0', digital_constellation_modulator_0, '0']
- [blocks_selector_1, '0', oqpsk_0, '0']
- [blocks_stream_mux_3, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_mux_4, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', txid_head_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_selector_1, '1']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_0_1, '0', blocks_selector_1, '1']
- [digital_constellation_modulator_0, '0', blocks_selector_0, '1']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_xx_0, '0']
- [null_0, '0', blocks_stream_mux_3, '0']
- [null_1, '0', blocks_stream_mux_3, '2']
- [null_2, '0', blocks_stream_mux_3, '4']
- [null_3, '0', blocks_stream_mux_4, '2']
- [oqpsk_0, '0', blocks_selector_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_mux_4, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, txid_udp_trigger_0, in]
- [preamble_vect, '0', blocks_stream_mux_3, '1']
- [txid_head_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [txid_udp_trigger_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
