<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>reciever</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>433e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>(1.00000000000000 + 0.00000000000000j, -0.0198821876650702 - 0.999802329770066j, 0.0596151251698190 + 0.998221436781933j, -0.992892073701974 + 0.119018191801903j, -0.980297366804636 + 0.197527397177953j, 0.293850274337919 + 0.955851461405761j, -0.405525320812986 - 0.914083811354038j, 0.848983362091364 - 0.528419578452620j, 0.754564620158230 - 0.656225749270376j, -0.780057308185211 - 0.625708075660561j, 0.888282612749130 + 0.459297289222982j, -0.255616632440464 + 0.966778225458040j, -0.0198821876650804 + 0.999802329770065j, 0.971669340040416 - 0.236344438532879j, -0.869320274439587 + 0.494249188616716j, -0.727878810369485 - 0.685705795086423j, -0.905840393665518 - 0.423619146408540j, -0.0992537989080696 + 0.995062150522427j, -0.255616632440477 - 0.966778225458036j, 0.804316565270771 - 0.594201028971703j, 0.511435479103437 - 0.859321680579653j, -0.992892073701971 - 0.119018191801923j, 0.949820131727787 - 0.312796607022213j, 0.700042074569421 + 0.714101599096754j, 0.949820131727768 + 0.312796607022273j, -0.177997895677522 - 0.984030867978426j, 0.641093637592130 + 0.767462668693983j, -0.331619278552096 + 0.943413299722125j, 0.216978808106213 + 0.976176314419074j, 0.700042074569433 - 0.714101599096743j, -0.177997895677626 + 0.984030867978407j, -0.905840393665558 + 0.423619146408453j, -0.476867501428628 + 0.878975190822367j, 0.987375341936355 - 0.158398024407083j, -0.671098428359002 + 0.741368261698650j, -0.999209397227295 - 0.0397565150970890j, -0.780057308185194 + 0.625708075660582j, 0.987375341936324 + 0.158398024407273j, -0.827304032543040 + 0.561754428320796j, -0.980297366804605 - 0.197527397178109j, -0.827304032543027 + 0.561754428320816j, 0.987375341936332 + 0.158398024407226j, -0.780057308185292 + 0.625708075660460j, -0.999209397227299 - 0.0397565150969950j, -0.671098428359083 + 0.741368261698577j, 0.987375341936350 - 0.158398024407110j, -0.476867501428484 + 0.878975190822446j, -0.905840393665478 + 0.423619146408624j, -0.177997895677642 + 0.984030867978404j, 0.700042074569508 - 0.714101599096669j, 0.216978808106132 + 0.976176314419092j, -0.331619278552151 + 0.943413299722105j, 0.641093637592190 + 0.767462668693933j, -0.177997895677511 - 0.984030867978428j, 0.949820131727754 + 0.312796607022316j, 0.700042074569284 + 0.714101599096888j, 0.949820131727893 - 0.312796607021891j, -0.992892073701961 - 0.119018191802010j, 0.511435479103736 - 0.859321680579474j, 0.804316565270626 - 0.594201028971898j, -0.255616632440350 - 0.966778225458070j, -0.0992537989081486 + 0.995062150522419j, -0.905840393665482 - 0.423619146408617j, -0.727878810369385 - 0.685705795086529j, -0.869320274439717 + 0.494249188616486j, 0.971669340040621 - 0.236344438532038j, -0.0198821876652695 + 0.999802329770062j, -0.255616632440926 + 0.966778225457918j, 0.888282612749188 + 0.459297289222869j, -0.780057308185057 - 0.625708075660753j, 0.754564620158670 - 0.656225749269870j, 0.848983362091728 - 0.528419578452034j, -0.405525320812299 - 0.914083811354343j, 0.293850274337947 + 0.955851461405753j, -0.980297366804665 + 0.197527397177809j, -0.992892073702018 + 0.119018191801536j, 0.0596151251691726 + 0.998221436781972j, -0.0198821876650031 - 0.999802329770067j, 1.00000000000000 + 4.46840285540623e-13j)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rx_gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_2</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_2_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_3</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_3_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_4</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_4_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_5</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_5_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_6</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_6_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_7</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_7_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_8</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_0_9</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1_2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>file_re+'_0'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>file_im+'_0'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>file_im+'_1'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>file_im+'_2'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0</value></param>
<param><key>file</key><value>file_im+'_13'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1</value></param>
<param><key>file</key><value>file_im+'_3'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0</value></param>
<param><key>file</key><value>file_im+'_14'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_2</value></param>
<param><key>file</key><value>file_im+'_4'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_2_0</value></param>
<param><key>file</key><value>file_im+'_15'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_3</value></param>
<param><key>file</key><value>file_im+'_5'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_3_0</value></param>
<param><key>file</key><value>file_im+'_16'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_4</value></param>
<param><key>file</key><value>file_im+'_6'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_4_0</value></param>
<param><key>file</key><value>file_im+'_17'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_5</value></param>
<param><key>file</key><value>file_im+'_7'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_5_0</value></param>
<param><key>file</key><value>file_im+'_18'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_6</value></param>
<param><key>file</key><value>file_im+'_8'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_6_0</value></param>
<param><key>file</key><value>file_im+'_19'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_7</value></param>
<param><key>file</key><value>file_im+'_9'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_7_0</value></param>
<param><key>file</key><value>file_im+'_20'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_8</value></param>
<param><key>file</key><value>file_im+'_10'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_9</value></param>
<param><key>file</key><value>file_im+'_12'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_im</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_2</value></param>
<param><key>file</key><value>file_im+'_11'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>file</key><value>file_re+'_1'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0</value></param>
<param><key>file</key><value>file_re+'_2'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_0</value></param>
<param><key>file</key><value>file_re+'_13'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_1</value></param>
<param><key>file</key><value>file_re+'_3'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_1_0</value></param>
<param><key>file</key><value>file_re+'_14'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_2</value></param>
<param><key>file</key><value>file_re+'_4'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_2_0</value></param>
<param><key>file</key><value>file_re+'_15'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3</value></param>
<param><key>file</key><value>file_re+'_5'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0</value></param>
<param><key>file</key><value>file_re+'_16'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_4</value></param>
<param><key>file</key><value>file_re+'_6'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_4_0</value></param>
<param><key>file</key><value>file_re+'_17'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_5</value></param>
<param><key>file</key><value>file_re+'_7'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_5_0</value></param>
<param><key>file</key><value>file_re+'_18'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_6</value></param>
<param><key>file</key><value>file_re+'_8'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_6_0</value></param>
<param><key>file</key><value>file_re+'_19'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_7</value></param>
<param><key>file</key><value>file_re+'_9'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_7_0</value></param>
<param><key>file</key><value>file_re+'_20'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_8</value></param>
<param><key>file</key><value>file_re+'_10'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_9</value></param>
<param><key>file</key><value>file_re+'_12'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_re</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_3</value></param>
<param><key>file</key><value>file_re+'_11'+'.bin'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>1000000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"rx_len"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_im</value></param>
<param><key>short_id</key><value>I</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>enreg_im</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_re</value></param>
<param><key>short_id</key><value>R</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>enreg_re</value></param>
</block>
<block>
<key>learning_correlator</key>
<param><key>id</key><value>learning_correlator_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>preamble</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold_method</key><value>digital.corr_est_cc.THRESHOLD_DYNAMIC</value></param>
<param><key>threshold</key><value>0.3</value></param>
</block>
<block>
<key>learning_data_switch</key>
<param><key>id</key><value>learning_data_switch_0</value></param>
<param><key>header_size</key><value>380</value></param>
<param><key>payload_size</key><value>600</value></param>
<param><key>to_server</key><value>False</value></param>
<param><key>address</key><value>127.0.0.1</value></param>
<param><key>port</key><value>3581</value></param>
<param><key>tx_amount</key><value>tx_amount</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_0_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_1</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_1_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_2</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_2_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_3</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_3_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_4</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_4_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_5</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_5_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_6</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_6_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_7</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_7_0</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_8</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_0_9</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_0_1</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>num_items</key><value>nb_samples_to_save</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_head</key>
<param><key>id</key><value>learning_head_1</value></param>
<param><key>blocking</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>nb_samples_to_save/100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>learning_packet_isolator_c</key>
<param><key>id</key><value>learning_packet_isolator_c_0</value></param>
<param><key>lookup_window</key><value>200</value></param>
<param><key>minoutbuf</key><value>2000</value></param>
<param><key>payload_length</key><value>980</value></param>
<param><key>preamble_length</key><value>100</value></param>
<param><key>tag_name</key><value>"corr_est"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nb_samples_to_save</value></param>
<param><key>short_id</key><value>S</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>600*(50000 + 2000)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_amount</value></param>
<param><key>short_id</key><value>T</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>usrp_rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_1</source_block_id><sink_block_id>blocks_file_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_1_0</source_block_id><sink_block_id>blocks_file_sink_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_2</source_block_id><sink_block_id>blocks_file_sink_0_0_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_2</source_block_id><sink_block_id>blocks_file_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_2_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_2_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_2_0</source_block_id><sink_block_id>blocks_file_sink_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_3</source_block_id><sink_block_id>blocks_file_sink_0_0_0_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_3</source_block_id><sink_block_id>blocks_file_sink_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_3_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_3_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_3_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_4</source_block_id><sink_block_id>blocks_file_sink_0_0_0_4</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_4</source_block_id><sink_block_id>blocks_file_sink_0_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_4_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_4_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_4_0</source_block_id><sink_block_id>blocks_file_sink_0_1_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_5</source_block_id><sink_block_id>blocks_file_sink_0_0_0_5</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_5</source_block_id><sink_block_id>blocks_file_sink_0_1_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_5_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_5_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_5_0</source_block_id><sink_block_id>blocks_file_sink_0_1_5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_6</source_block_id><sink_block_id>blocks_file_sink_0_0_0_6</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_6</source_block_id><sink_block_id>blocks_file_sink_0_1_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_6_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_6_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_6_0</source_block_id><sink_block_id>blocks_file_sink_0_1_6_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_7</source_block_id><sink_block_id>blocks_file_sink_0_0_0_7</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_7</source_block_id><sink_block_id>blocks_file_sink_0_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_7_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_7_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_7_0</source_block_id><sink_block_id>blocks_file_sink_0_1_7_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_8</source_block_id><sink_block_id>blocks_file_sink_0_0_0_8</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_8</source_block_id><sink_block_id>blocks_file_sink_0_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_9</source_block_id><sink_block_id>blocks_file_sink_0_0_0_9</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_0_9</source_block_id><sink_block_id>blocks_file_sink_0_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_1</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_1</source_block_id><sink_block_id>blocks_file_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_2</source_block_id><sink_block_id>blocks_file_sink_0_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1_2</source_block_id><sink_block_id>blocks_file_sink_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>learning_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>learning_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>learning_data_switch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_correlator_0</source_block_id><sink_block_id>learning_packet_isolator_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_8</sink_block_id><source_key>10</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_1</sink_block_id><source_key>11</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_9</sink_block_id><source_key>12</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_0_0</sink_block_id><source_key>13</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_1_0</sink_block_id><source_key>14</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_2_0</sink_block_id><source_key>15</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_3_0</sink_block_id><source_key>16</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_4_0</sink_block_id><source_key>17</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_5_0</sink_block_id><source_key>18</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_6_0</sink_block_id><source_key>19</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_7_0</sink_block_id><source_key>20</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_3</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_4</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_5</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_6</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_data_switch_0</source_block_id><sink_block_id>learning_head_0_0_7</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0</source_block_id><sink_block_id>blocks_complex_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_1</source_block_id><sink_block_id>blocks_complex_to_float_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_1_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_2</source_block_id><sink_block_id>blocks_complex_to_float_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_2_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_3</source_block_id><sink_block_id>blocks_complex_to_float_1_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_3_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_4</source_block_id><sink_block_id>blocks_complex_to_float_1_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_4_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_5</source_block_id><sink_block_id>blocks_complex_to_float_1_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_5_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_6</source_block_id><sink_block_id>blocks_complex_to_float_1_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_6_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_6_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_7</source_block_id><sink_block_id>blocks_complex_to_float_1_0_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_7_0</source_block_id><sink_block_id>blocks_complex_to_float_1_0_7_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_8</source_block_id><sink_block_id>blocks_complex_to_float_1_0_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_0_9</source_block_id><sink_block_id>blocks_complex_to_float_1_0_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_0_1</source_block_id><sink_block_id>blocks_complex_to_float_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_head_1</source_block_id><sink_block_id>blocks_complex_to_float_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_packet_isolator_c_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>learning_packet_isolator_c_0</source_block_id><sink_block_id>learning_data_switch_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
