options:
  parameters:
    author: Cyrille Morin
    generate_options: no_gui
    id: reciever
    output_language: python
    run_options: run
    title: Tx Id Reciever
  states: {}

blocks:
- name: full_header
  id: variable
  parameters:
    value: zpad+preamble_len+preamble_guard_len+ header_len + header_guard_len
  states: {}
- name: header_guard_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '400'
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '320'
  states: {state: disabled}
- name: payload_guard_len
  id: variable
  parameters:
    value: '200'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '560'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: (1.00000000000000 + 0.00000000000000j, -0.0198821876650702 - 0.999802329770066j, 0.0596151251698190 + 0.998221436781933j, -0.992892073701974 + 0.119018191801903j, -0.980297366804636 + 0.197527397177953j, 0.293850274337919 + 0.955851461405761j, -0.405525320812986 - 0.914083811354038j, 0.848983362091364 - 0.528419578452620j, 0.754564620158230 - 0.656225749270376j, -0.780057308185211 - 0.625708075660561j, 0.888282612749130 + 0.459297289222982j, -0.255616632440464 + 0.966778225458040j, -0.0198821876650804 + 0.999802329770065j, 0.971669340040416 - 0.236344438532879j, -0.869320274439587 + 0.494249188616716j, -0.727878810369485 - 0.685705795086423j, -0.905840393665518 - 0.423619146408540j, -0.0992537989080696 + 0.995062150522427j, -0.255616632440477 - 0.966778225458036j, 0.804316565270771 - 0.594201028971703j, 0.511435479103437 - 0.859321680579653j, -0.992892073701971 - 0.119018191801923j, 0.949820131727787 - 0.312796607022213j, 0.700042074569421 + 0.714101599096754j, 0.949820131727768 + 0.312796607022273j, -0.177997895677522 - 0.984030867978426j, 0.641093637592130 + 0.767462668693983j, -0.331619278552096 + 0.943413299722125j, 0.216978808106213 + 0.976176314419074j, 0.700042074569433 - 0.714101599096743j, -0.177997895677626 + 0.984030867978407j, -0.905840393665558 + 0.423619146408453j, -0.476867501428628 + 0.878975190822367j, 0.987375341936355 - 0.158398024407083j, -0.671098428359002 + 0.741368261698650j, -0.999209397227295 - 0.0397565150970890j, -0.780057308185194 + 0.625708075660582j, 0.987375341936324 + 0.158398024407273j, -0.827304032543040 + 0.561754428320796j, -0.980297366804605 - 0.197527397178109j, -0.827304032543027 + 0.561754428320816j, 0.987375341936332 + 0.158398024407226j, -0.780057308185292 + 0.625708075660460j, -0.999209397227299 - 0.0397565150969950j, -0.671098428359083 + 0.741368261698577j, 0.987375341936350 - 0.158398024407110j, -0.476867501428484 + 0.878975190822446j, -0.905840393665478 + 0.423619146408624j, -0.177997895677642 + 0.984030867978404j, 0.700042074569508 - 0.714101599096669j, 0.216978808106132 + 0.976176314419092j, -0.331619278552151 + 0.943413299722105j, 0.641093637592190 + 0.767462668693933j, -0.177997895677511 - 0.984030867978428j, 0.949820131727754 + 0.312796607022316j, 0.700042074569284 + 0.714101599096888j, 0.949820131727893 - 0.312796607021891j, -0.992892073701961 - 0.119018191802010j, 0.511435479103736 - 0.859321680579474j, 0.804316565270626 - 0.594201028971898j, -0.255616632440350 - 0.966778225458070j, -0.0992537989081486 + 0.995062150522419j, -0.905840393665482 - 0.423619146408617j, -0.727878810369385 - 0.685705795086529j, -0.869320274439717 + 0.494249188616486j, 0.971669340040621 - 0.236344438532038j, -0.0198821876652695 + 0.999802329770062j, -0.255616632440926 + 0.966778225457918j, 0.888282612749188 + 0.459297289222869j, -0.780057308185057 - 0.625708075660753j, 0.754564620158670 - 0.656225749269870j, 0.848983362091728 - 0.528419578452034j, -0.405525320812299 - 0.914083811354343j, 0.293850274337947 + 0.955851461405753j, -0.980297366804665 + 0.197527397177809j, -0.992892073702018 + 0.119018191801536j, 0.0596151251691726 + 0.998221436781972j, -0.0198821876650031 - 0.999802329770067j, 1.00000000000000 + 4.46840285540623e-13j)
  states: {}
- name: preamble_guard_len
  id: variable
  parameters:
    value: '40'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: len(preamble)
  states: {}
- name: zpad
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '5'
    type: float
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1000000'
    type: complex
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: c
    type: eng_float
    value: 433e6
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: '"rx_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    scramble_bits: 'True'
    sync_word1: ''
    sync_word2: ''
  states: {state: disabled}
- name: file
  id: parameter
  parameters:
    label: Base Filename
    short_id: F
    type: str
    value: enreg
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: nb_payloads_to_save
  id: parameter
  parameters:
    label: Payloads to save
    short_id: r
    type: intx
    value: (50000 + 2000)
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '280'
    size: '100'
    type: float
    xmax: '27'
    xmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10'
    srate: samp_rate
    type: float
    ymax: '30'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    short_id: a
    type: intx
    value: '5000000'
  states: {}
- name: tx_amount
  id: parameter
  parameters:
    label: Transmitter amount
    short_id: T
    type: intx
    value: '21'
  states: {}
- name: txid_correlator_0
  id: txid_correlator
  parameters:
    mark_delay: '0'
    sps: '1'
    symbols: preamble
    threshold: '0.3'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: txid_ofdm_rx_0
  id: txid_ofdm_rx
  parameters:
    check_len: 5+4
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    log: 'False'
    occupied_carriers: ''
    packet_len_key: '"length"'
    payload_mod: '"BPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    sc_thresh: '0.9'
    scramble_bits: 'True'
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: txid_packet_isolator_c_0
  id: txid_packet_isolator_c
  parameters:
    lookup_window: '200'
    minoutbuf: '2000'
    payload_length: (preamble_guard_len//2)-1+header_len+header_guard_len+payload_len+payload_guard_len//2
    preamble_length: preamble_len+(preamble_guard_len//2)+1
    tag_name: '"corr_est"'
  states: {}
- name: txid_record_payload_0
  id: txid_record_payload
  parameters:
    base_filename: file
    header_size: (preamble_guard_len//2)-1+header_len+header_guard_len-20
    payload_size: '600'
    payloads_to_save: nb_payloads_to_save
    server_ip: 127.0.0.1
    server_port: '3581'
    to_server: 'False'
    tx_amount: tx_amount
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: usrp_rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: usrp_rx_gain
  id: parameter
  parameters:
    label: RX Gain
    short_id: g
    type: eng_float
    value: '20'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_skiphead_0, '0', txid_correlator_0, '0']
- [digital_ofdm_rx_0, '0', blocks_char_to_float_0, '0']
- [digital_ofdm_rx_0, '0', txid_record_payload_0, '0']
- [txid_correlator_0, '0', qtgui_time_sink_x_1, '0']
- [txid_correlator_0, '0', txid_packet_isolator_c_0, '0']
- [txid_ofdm_rx_0, '0', blocks_char_to_float_0, '0']
- [txid_ofdm_rx_0, '0', txid_record_payload_0, '0']
- [txid_packet_isolator_c_0, '0', digital_ofdm_rx_0, '0']
- [txid_packet_isolator_c_0, '0', txid_ofdm_rx_0, '0']
- [txid_packet_isolator_c_0, '0', txid_record_payload_0, '1']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
