options:
  parameters:
    generate_options: no_gui
    id: reciever
    output_language: python
    run_options: run
  states: {}

blocks:
- name: preamble
  id: variable
  parameters:
    value: (1.00000000000000 + 0.00000000000000j, -0.0198821876650702 - 0.999802329770066j, 0.0596151251698190 + 0.998221436781933j, -0.992892073701974 + 0.119018191801903j, -0.980297366804636 + 0.197527397177953j, 0.293850274337919 + 0.955851461405761j, -0.405525320812986 - 0.914083811354038j, 0.848983362091364 - 0.528419578452620j, 0.754564620158230 - 0.656225749270376j, -0.780057308185211 - 0.625708075660561j, 0.888282612749130 + 0.459297289222982j, -0.255616632440464 + 0.966778225458040j, -0.0198821876650804 + 0.999802329770065j, 0.971669340040416 - 0.236344438532879j, -0.869320274439587 + 0.494249188616716j, -0.727878810369485 - 0.685705795086423j, -0.905840393665518 - 0.423619146408540j, -0.0992537989080696 + 0.995062150522427j, -0.255616632440477 - 0.966778225458036j, 0.804316565270771 - 0.594201028971703j, 0.511435479103437 - 0.859321680579653j, -0.992892073701971 - 0.119018191801923j, 0.949820131727787 - 0.312796607022213j, 0.700042074569421 + 0.714101599096754j, 0.949820131727768 + 0.312796607022273j, -0.177997895677522 - 0.984030867978426j, 0.641093637592130 + 0.767462668693983j, -0.331619278552096 + 0.943413299722125j, 0.216978808106213 + 0.976176314419074j, 0.700042074569433 - 0.714101599096743j, -0.177997895677626 + 0.984030867978407j, -0.905840393665558 + 0.423619146408453j, -0.476867501428628 + 0.878975190822367j, 0.987375341936355 - 0.158398024407083j, -0.671098428359002 + 0.741368261698650j, -0.999209397227295 - 0.0397565150970890j, -0.780057308185194 + 0.625708075660582j, 0.987375341936324 + 0.158398024407273j, -0.827304032543040 + 0.561754428320796j, -0.980297366804605 - 0.197527397178109j, -0.827304032543027 + 0.561754428320816j, 0.987375341936332 + 0.158398024407226j, -0.780057308185292 + 0.625708075660460j, -0.999209397227299 - 0.0397565150969950j, -0.671098428359083 + 0.741368261698577j, 0.987375341936350 - 0.158398024407110j, -0.476867501428484 + 0.878975190822446j, -0.905840393665478 + 0.423619146408624j, -0.177997895677642 + 0.984030867978404j, 0.700042074569508 - 0.714101599096669j, 0.216978808106132 + 0.976176314419092j, -0.331619278552151 + 0.943413299722105j, 0.641093637592190 + 0.767462668693933j, -0.177997895677511 - 0.984030867978428j, 0.949820131727754 + 0.312796607022316j, 0.700042074569284 + 0.714101599096888j, 0.949820131727893 - 0.312796607021891j, -0.992892073701961 - 0.119018191802010j, 0.511435479103736 - 0.859321680579474j, 0.804316565270626 - 0.594201028971898j, -0.255616632440350 - 0.966778225458070j, -0.0992537989081486 + 0.995062150522419j, -0.905840393665482 - 0.423619146408617j, -0.727878810369385 - 0.685705795086529j, -0.869320274439717 + 0.494249188616486j, 0.971669340040621 - 0.236344438532038j, -0.0198821876652695 + 0.999802329770062j, -0.255616632440926 + 0.966778225457918j, 0.888282612749188 + 0.459297289222869j, -0.780057308185057 - 0.625708075660753j, 0.754564620158670 - 0.656225749269870j, 0.848983362091728 - 0.528419578452034j, -0.405525320812299 - 0.914083811354343j, 0.293850274337947 + 0.955851461405753j, -0.980297366804665 + 0.197527397177809j, -0.992892073702018 + 0.119018191801536j, 0.0596151251691726 + 0.998221436781972j, -0.0198821876650031 - 0.999802329770067j, 1.00000000000000 + 4.46840285540623e-13j)
  states: {}
- name: usrp_rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_2_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_3
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_3_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_4
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_4_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_5
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_5_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_6
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_6_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_7
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_7_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_8
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0_9
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_0'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_0'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_1'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_2'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_13'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: file_im+'_3'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_14'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_2
  id: blocks_file_sink
  parameters:
    file: file_im+'_4'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_2_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_15'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_3
  id: blocks_file_sink
  parameters:
    file: file_im+'_5'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_3_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_16'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_4
  id: blocks_file_sink
  parameters:
    file: file_im+'_6'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_4_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_17'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_5
  id: blocks_file_sink
  parameters:
    file: file_im+'_7'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_5_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_18'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_6
  id: blocks_file_sink
  parameters:
    file: file_im+'_8'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_6_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_19'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_7
  id: blocks_file_sink
  parameters:
    file: file_im+'_9'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_7_0
  id: blocks_file_sink
  parameters:
    file: file_im+'_20'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_8
  id: blocks_file_sink
  parameters:
    file: file_im+'_10'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_9
  id: blocks_file_sink
  parameters:
    file: file_im+'_12'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: file_im
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: file_im+'_11'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: file_re+'_1'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_2'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_13'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_1
  id: blocks_file_sink
  parameters:
    file: file_re+'_3'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_1_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_14'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_2
  id: blocks_file_sink
  parameters:
    file: file_re+'_4'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_2_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_15'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_3
  id: blocks_file_sink
  parameters:
    file: file_re+'_5'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_3_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_16'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_4
  id: blocks_file_sink
  parameters:
    file: file_re+'_6'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_4_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_17'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_5
  id: blocks_file_sink
  parameters:
    file: file_re+'_7'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_5_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_18'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_6
  id: blocks_file_sink
  parameters:
    file: file_re+'_8'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_6_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_19'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_7
  id: blocks_file_sink
  parameters:
    file: file_re+'_9'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_7_0
  id: blocks_file_sink
  parameters:
    file: file_re+'_20'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_8
  id: blocks_file_sink
  parameters:
    file: file_re+'_10'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_1_9
  id: blocks_file_sink
  parameters:
    file: file_re+'_12'+'.bin'
    type: float
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: file_re
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: file_re+'_11'+'.bin'
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1000000'
    type: complex
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: c
    type: eng_float
    value: 433e6
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ''
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ''
    pilot_symbols: ''
    sync_word1: ''
    sync_word2: ''
  states: {}
- name: file_im
  id: parameter
  parameters:
    short_id: I
    type: str
    value: enreg_im
  states: {}
- name: file_re
  id: parameter
  parameters:
    short_id: R
    type: str
    value: enreg_re
  states: {}
- name: nb_samples_to_save
  id: parameter
  parameters:
    short_id: S
    type: intx
    value: 600*(50000 + 2000)
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    short_id: a
    type: intx
    value: '5000000'
  states: {}
- name: tx_amount
  id: parameter
  parameters:
    short_id: T
    type: intx
    value: '21'
  states: {}
- name: txid_correlator_0
  id: txid_correlator
  parameters:
    mark_delay: '0'
    sps: '1'
    symbols: preamble
    threshold: '0.3'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: txid_data_switch_0
  id: txid_data_switch
  parameters:
    address: 127.0.0.1
    header_size: '379'
    payload_size: '600'
    port: '3581'
    to_server: 'False'
    tx_amount: tx_amount
  states: {}
- name: txid_head_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_0_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_1
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_1_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_2
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_2_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_3
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_3_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_4
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_4_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_5
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_5_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_6
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_6_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_7
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_7_0
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_8
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_0_9
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_0_1
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: nb_samples_to_save
    type: complex
    vlen: '1'
  states: {}
- name: txid_head_1
  id: txid_head
  parameters:
    blocking: 'False'
    num_items: samp_rate * 10
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: txid_packet_isolator_c_0
  id: txid_packet_isolator_c
  parameters:
    lookup_window: '200'
    minoutbuf: '2000'
    payload_length: '979'
    preamble_length: '100'
    tag_name: '"corr_est"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: internal
    dev_args: '""'
    gain0: usrp_rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_1, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_float_1, '1', blocks_file_sink_0_0, '0']
- [blocks_complex_to_float_1_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_float_1_0, '1', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_float_1_0_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_complex_to_float_1_0_0, '1', blocks_file_sink_0_0_0_0, '0']
- [blocks_complex_to_float_1_0_0_0, '0', blocks_file_sink_0_1_0_0, '0']
- [blocks_complex_to_float_1_0_0_0, '1', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_complex_to_float_1_0_1, '0', blocks_file_sink_0_1_1, '0']
- [blocks_complex_to_float_1_0_1, '1', blocks_file_sink_0_0_0_1, '0']
- [blocks_complex_to_float_1_0_1_0, '0', blocks_file_sink_0_1_1_0, '0']
- [blocks_complex_to_float_1_0_1_0, '1', blocks_file_sink_0_0_0_1_0, '0']
- [blocks_complex_to_float_1_0_2, '0', blocks_file_sink_0_1_2, '0']
- [blocks_complex_to_float_1_0_2, '1', blocks_file_sink_0_0_0_2, '0']
- [blocks_complex_to_float_1_0_2_0, '0', blocks_file_sink_0_1_2_0, '0']
- [blocks_complex_to_float_1_0_2_0, '1', blocks_file_sink_0_0_0_2_0, '0']
- [blocks_complex_to_float_1_0_3, '0', blocks_file_sink_0_1_3, '0']
- [blocks_complex_to_float_1_0_3, '1', blocks_file_sink_0_0_0_3, '0']
- [blocks_complex_to_float_1_0_3_0, '0', blocks_file_sink_0_1_3_0, '0']
- [blocks_complex_to_float_1_0_3_0, '1', blocks_file_sink_0_0_0_3_0, '0']
- [blocks_complex_to_float_1_0_4, '0', blocks_file_sink_0_1_4, '0']
- [blocks_complex_to_float_1_0_4, '1', blocks_file_sink_0_0_0_4, '0']
- [blocks_complex_to_float_1_0_4_0, '0', blocks_file_sink_0_1_4_0, '0']
- [blocks_complex_to_float_1_0_4_0, '1', blocks_file_sink_0_0_0_4_0, '0']
- [blocks_complex_to_float_1_0_5, '0', blocks_file_sink_0_1_5, '0']
- [blocks_complex_to_float_1_0_5, '1', blocks_file_sink_0_0_0_5, '0']
- [blocks_complex_to_float_1_0_5_0, '0', blocks_file_sink_0_1_5_0, '0']
- [blocks_complex_to_float_1_0_5_0, '1', blocks_file_sink_0_0_0_5_0, '0']
- [blocks_complex_to_float_1_0_6, '0', blocks_file_sink_0_1_6, '0']
- [blocks_complex_to_float_1_0_6, '1', blocks_file_sink_0_0_0_6, '0']
- [blocks_complex_to_float_1_0_6_0, '0', blocks_file_sink_0_1_6_0, '0']
- [blocks_complex_to_float_1_0_6_0, '1', blocks_file_sink_0_0_0_6_0, '0']
- [blocks_complex_to_float_1_0_7, '0', blocks_file_sink_0_1_7, '0']
- [blocks_complex_to_float_1_0_7, '1', blocks_file_sink_0_0_0_7, '0']
- [blocks_complex_to_float_1_0_7_0, '0', blocks_file_sink_0_1_7_0, '0']
- [blocks_complex_to_float_1_0_7_0, '1', blocks_file_sink_0_0_0_7_0, '0']
- [blocks_complex_to_float_1_0_8, '0', blocks_file_sink_0_1_8, '0']
- [blocks_complex_to_float_1_0_8, '1', blocks_file_sink_0_0_0_8, '0']
- [blocks_complex_to_float_1_0_9, '0', blocks_file_sink_0_1_9, '0']
- [blocks_complex_to_float_1_0_9, '1', blocks_file_sink_0_0_0_9, '0']
- [blocks_complex_to_float_1_1, '0', blocks_file_sink_0_2, '0']
- [blocks_complex_to_float_1_1, '1', blocks_file_sink_0_0_1, '0']
- [blocks_complex_to_float_1_2, '0', blocks_file_sink_0_3, '0']
- [blocks_complex_to_float_1_2, '1', blocks_file_sink_0_0_2, '0']
- [blocks_skiphead_0, '0', txid_correlator_0, '0']
- [blocks_skiphead_0, '0', txid_head_1, '0']
- [digital_ofdm_rx_0, '0', txid_data_switch_0, '0']
- [txid_correlator_0, '0', txid_packet_isolator_c_0, '0']
- [txid_data_switch_0, '0', txid_head_0, '0']
- [txid_data_switch_0, '1', txid_head_0_0, '0']
- [txid_data_switch_0, '10', txid_head_0_0_8, '0']
- [txid_data_switch_0, '11', txid_head_0_1, '0']
- [txid_data_switch_0, '12', txid_head_0_0_9, '0']
- [txid_data_switch_0, '13', txid_head_0_0_0_0, '0']
- [txid_data_switch_0, '14', txid_head_0_0_1_0, '0']
- [txid_data_switch_0, '15', txid_head_0_0_2_0, '0']
- [txid_data_switch_0, '16', txid_head_0_0_3_0, '0']
- [txid_data_switch_0, '17', txid_head_0_0_4_0, '0']
- [txid_data_switch_0, '18', txid_head_0_0_5_0, '0']
- [txid_data_switch_0, '19', txid_head_0_0_6_0, '0']
- [txid_data_switch_0, '2', txid_head_0_0_0, '0']
- [txid_data_switch_0, '20', txid_head_0_0_7_0, '0']
- [txid_data_switch_0, '3', txid_head_0_0_1, '0']
- [txid_data_switch_0, '4', txid_head_0_0_2, '0']
- [txid_data_switch_0, '5', txid_head_0_0_3, '0']
- [txid_data_switch_0, '6', txid_head_0_0_4, '0']
- [txid_data_switch_0, '7', txid_head_0_0_5, '0']
- [txid_data_switch_0, '8', txid_head_0_0_6, '0']
- [txid_data_switch_0, '9', txid_head_0_0_7, '0']
- [txid_head_0, '0', blocks_complex_to_float_1, '0']
- [txid_head_0_0, '0', blocks_complex_to_float_1_0, '0']
- [txid_head_0_0_0, '0', blocks_complex_to_float_1_0_0, '0']
- [txid_head_0_0_0_0, '0', blocks_complex_to_float_1_0_0_0, '0']
- [txid_head_0_0_1, '0', blocks_complex_to_float_1_0_1, '0']
- [txid_head_0_0_1_0, '0', blocks_complex_to_float_1_0_1_0, '0']
- [txid_head_0_0_2, '0', blocks_complex_to_float_1_0_2, '0']
- [txid_head_0_0_2_0, '0', blocks_complex_to_float_1_0_2_0, '0']
- [txid_head_0_0_3, '0', blocks_complex_to_float_1_0_3, '0']
- [txid_head_0_0_3_0, '0', blocks_complex_to_float_1_0_3_0, '0']
- [txid_head_0_0_4, '0', blocks_complex_to_float_1_0_4, '0']
- [txid_head_0_0_4_0, '0', blocks_complex_to_float_1_0_4_0, '0']
- [txid_head_0_0_5, '0', blocks_complex_to_float_1_0_5, '0']
- [txid_head_0_0_5_0, '0', blocks_complex_to_float_1_0_5_0, '0']
- [txid_head_0_0_6, '0', blocks_complex_to_float_1_0_6, '0']
- [txid_head_0_0_6_0, '0', blocks_complex_to_float_1_0_6_0, '0']
- [txid_head_0_0_7, '0', blocks_complex_to_float_1_0_7, '0']
- [txid_head_0_0_7_0, '0', blocks_complex_to_float_1_0_7_0, '0']
- [txid_head_0_0_8, '0', blocks_complex_to_float_1_0_8, '0']
- [txid_head_0_0_9, '0', blocks_complex_to_float_1_0_9, '0']
- [txid_head_0_1, '0', blocks_complex_to_float_1_2, '0']
- [txid_head_1, '0', blocks_complex_to_float_1_1, '0']
- [txid_packet_isolator_c_0, '0', digital_ofdm_rx_0, '0']
- [txid_packet_isolator_c_0, '0', txid_data_switch_0, '1']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
