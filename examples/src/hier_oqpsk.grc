options:
  parameters:
    author: Cyrille Morin
    description: Expects 1 useful bit per input sample, not full bytes
    generate_options: hb
    id: oqpsk
    output_language: python
    title: OQPSK Modulator
  states: {}

blocks:
- name: repeat
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: float
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[1, -1]'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: roll_off_factor
  id: parameter
  parameters:
    label: Roll Off factor
    value: '0.3'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: roll_off_factor
    gain: samples_per_symbols / repeat
    interp: int(samples_per_symbols / repeat)
    ntaps: 11*samples_per_symbols
    samp_rate: samp_rate
    sym_rate: samp_rate / samples_per_symbols
    type: interp_fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: intx
    value: '32000'
  states: {}
- name: samples_per_symbols
  id: parameter
  parameters:
    label: Samples per Symbol
    value: '2'
  states: {}

connections:
- [blocks_delay_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_repeat_0, '0', blocks_delay_0, '0']
- [blocks_repeat_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_stream_demux_0, '0', blocks_repeat_0_0, '0']
- [blocks_stream_demux_0, '1', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_demux_0, '0']
- [pad_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [root_raised_cosine_filter_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
